## config/boards/shields/dumbpad/Kconfig.defconfig
```kconfig
if SHIELD_DUMBPAD

config ZMK_KEYBOARD_NAME
    default "Dumbpad nRF52840"

endif
```
